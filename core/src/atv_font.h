// A 5 x 7 pixel font (upper case, digits and a few signs) for the analog TV test card. Drawn by hand for this project.
#pragma once
#include <array>
#include <cstdint>

namespace dect2 {

// Returns 7 rows of 5 bits (bit 4 = leftmost pixel) for a character; unknown characters give a blank. Lower case is shown as upper case.
inline const uint8_t* atvGlyph(char c) {
    struct G { char ch; const char* rows[7]; };
    static const G kFont[] = {
        {' ', {".....", ".....", ".....", ".....", ".....", ".....", "....."}},
        {'0', {".###.", "#...#", "#..##", "#.#.#", "##..#", "#...#", ".###."}},
        {'1', {"..#..", ".##..", "..#..", "..#..", "..#..", "..#..", ".###."}},
        {'2', {".###.", "#...#", "....#", "...#.", "..#..", ".#...", "#####"}},
        {'3', {".###.", "#...#", "....#", "..##.", "....#", "#...#", ".###."}},
        {'4', {"...#.", "..##.", ".#.#.", "#..#.", "#####", "...#.", "...#."}},
        {'5', {"#####", "#....", "####.", "....#", "....#", "#...#", ".###."}},
        {'6', {"..##.", ".#...", "#....", "####.", "#...#", "#...#", ".###."}},
        {'7', {"#####", "....#", "...#.", "..#..", ".#...", ".#...", ".#..."}},
        {'8', {".###.", "#...#", "#...#", ".###.", "#...#", "#...#", ".###."}},
        {'9', {".###.", "#...#", "#...#", ".####", "....#", "...#.", ".##.."}},
        {'A', {".###.", "#...#", "#...#", "#####", "#...#", "#...#", "#...#"}},
        {'B', {"####.", "#...#", "#...#", "####.", "#...#", "#...#", "####."}},
        {'C', {".###.", "#...#", "#....", "#....", "#....", "#...#", ".###."}},
        {'D', {"####.", "#...#", "#...#", "#...#", "#...#", "#...#", "####."}},
        {'E', {"#####", "#....", "#....", "####.", "#....", "#....", "#####"}},
        {'F', {"#####", "#....", "#....", "####.", "#....", "#....", "#...."}},
        {'G', {".###.", "#...#", "#....", "#.###", "#...#", "#...#", ".###."}},
        {'H', {"#...#", "#...#", "#...#", "#####", "#...#", "#...#", "#...#"}},
        {'I', {".###.", "..#..", "..#..", "..#..", "..#..", "..#..", ".###."}},
        {'J', {"..###", "...#.", "...#.", "...#.", "...#.", "#..#.", ".##.."}},
        {'K', {"#...#", "#..#.", "#.#..", "##...", "#.#..", "#..#.", "#...#"}},
        {'L', {"#....", "#....", "#....", "#....", "#....", "#....", "#####"}},
        {'M', {"#...#", "##.##", "#.#.#", "#.#.#", "#...#", "#...#", "#...#"}},
        {'N', {"#...#", "##..#", "#.#.#", "#..##", "#...#", "#...#", "#...#"}},
        {'O', {".###.", "#...#", "#...#", "#...#", "#...#", "#...#", ".###."}},
        {'P', {"####.", "#...#", "#...#", "####.", "#....", "#....", "#...."}},
        {'Q', {".###.", "#...#", "#...#", "#...#", "#.#.#", "#..#.", ".##.#"}},
        {'R', {"####.", "#...#", "#...#", "####.", "#.#..", "#..#.", "#...#"}},
        {'S', {".####", "#....", "#....", ".###.", "....#", "....#", "####."}},
        {'T', {"#####", "..#..", "..#..", "..#..", "..#..", "..#..", "..#.."}},
        {'U', {"#...#", "#...#", "#...#", "#...#", "#...#", "#...#", ".###."}},
        {'V', {"#...#", "#...#", "#...#", "#...#", "#...#", ".#.#.", "..#.."}},
        {'W', {"#...#", "#...#", "#...#", "#.#.#", "#.#.#", "##.##", "#...#"}},
        {'X', {"#...#", "#...#", ".#.#.", "..#..", ".#.#.", "#...#", "#...#"}},
        {'Y', {"#...#", "#...#", ".#.#.", "..#..", "..#..", "..#..", "..#.."}},
        {'Z', {"#####", "....#", "...#.", "..#..", ".#...", "#....", "#####"}},
        {':', {".....", "..#..", "..#..", ".....", "..#..", "..#..", "....."}},
        {'/', {"....#", "....#", "...#.", "..#..", ".#...", "#....", "#...."}},
        {'-', {".....", ".....", ".....", "#####", ".....", ".....", "....."}},
        {'.', {".....", ".....", ".....", ".....", ".....", ".##..", ".##.."}},
    };
    static const std::array<std::array<uint8_t, 7>, sizeof(kFont) / sizeof(kFont[0])> bits = [] {
        std::array<std::array<uint8_t, 7>, sizeof(kFont) / sizeof(kFont[0])> t{};
        for (size_t g = 0; g < t.size(); g++)
            for (int r = 0; r < 7; r++) {
                uint8_t v = 0;
                for (int x = 0; x < 5; x++) v = (uint8_t)((v << 1) | (kFont[g].rows[r][x] == '#' ? 1 : 0));
                t[g][(size_t)r] = v;
            }
        return t;
    }();
    if (c >= 'a' && c <= 'z') c = (char)(c - 'a' + 'A');
    for (size_t g = 0; g < sizeof(kFont) / sizeof(kFont[0]); g++) if (kFont[g].ch == c) return bits[g].data();
    return bits[0].data();
}

} // namespace dect2
